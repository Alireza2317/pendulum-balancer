Commit message: added mass and inertia to the rail in urdf, to supress warnings

File: assets/urdf/pendulum.urdf (robot description, URDF)
Before this commit: robot double_pendulum_rail, 4 links, 3 joints
Links:
- link rail: mass None -> 0.0
